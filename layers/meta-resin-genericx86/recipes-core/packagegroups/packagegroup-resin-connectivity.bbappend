CONNECTIVITY_FIRMWARES =+ "linux-firmware-ibt linux-firmware-rtl8723 linux-firmware-rtl8821"
