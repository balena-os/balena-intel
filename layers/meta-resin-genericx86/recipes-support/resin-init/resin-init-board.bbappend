FILESEXTRAPATHS_append_artik10 := "${THISDIR}/${PN}"
