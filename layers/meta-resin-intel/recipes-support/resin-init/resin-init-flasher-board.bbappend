FILESEXTRAPATHS_append_intel-corei7-64 := "${THISDIR}/${PN}"
