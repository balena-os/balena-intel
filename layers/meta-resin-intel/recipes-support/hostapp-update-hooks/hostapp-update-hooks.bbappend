FILESEXTRAPATHS_append := ":${THISDIR}/files"

HOSTAPP_HOOKS_append = " 99-resin-grub"
