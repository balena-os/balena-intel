PACKAGE_INSTALL_append = " initramfs-module-labelrootfs"
