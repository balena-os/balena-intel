CONNECTIVITY_FIRMWARES =+ "linux-firmware-ibt"
