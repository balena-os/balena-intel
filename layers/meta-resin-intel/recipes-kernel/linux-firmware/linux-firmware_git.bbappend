PACKAGES =+ "${PN}-ibt"

FILES_${PN}-ibt = " \
    /lib/firmware/intel/ibt-11-5.ddc \
    /lib/firmware/intel/ibt-11-5.sfi \
    /lib/firmware/intel/ibt-12-16.ddc \
    /lib/firmware/intel/ibt-12-16.sfi \
    /lib/firmware/intel/ibt-hw-37.8.bseq \
    /lib/firmware/intel/ibt-hw-37.8.10-fw-1.10.3.11.e.bseq \
    "
