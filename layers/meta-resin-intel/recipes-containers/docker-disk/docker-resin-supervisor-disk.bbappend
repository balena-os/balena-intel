TARGET_REPOSITORY_intel-corei7-64 = "resin/amd64-supervisor"
LED_FILE_intel-corei7-64 = "/dev/null"
