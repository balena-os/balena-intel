FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI += "file://0001-gen_mod_headers-Use-native-fixdep-for-target-objtool.patch"
