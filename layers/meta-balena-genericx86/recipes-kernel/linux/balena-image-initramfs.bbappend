PACKAGE_INSTALL_append_genericx86-64-ext = " initramfs-module-cryptsetup initramfs-module-kexec"
