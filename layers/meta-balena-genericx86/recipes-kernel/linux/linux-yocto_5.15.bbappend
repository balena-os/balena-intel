# pky meta-yocto-bsp still pins genericx86-64 to 5.15.150, override it with 5.15.223
SRCREV_machine:genericx86-64 = "1d6ebc5d971a9ceaaca66d449147c2c5da9b7701"
SRCREV_machine:genericx86-64-ext = "1d6ebc5d971a9ceaaca66d449147c2c5da9b7701"
LINUX_VERSION:genericx86-64 = "5.15.223"
LINUX_VERSION:genericx86-64-ext = "5.15.223"