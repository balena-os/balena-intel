PACKAGE_INSTALL_append = " efibootmgr"
